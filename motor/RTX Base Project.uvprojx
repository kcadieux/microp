# Keil uVision project RTX Base Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTX Base Project
  c flags: Optim=1 wLevel=2
  c define: HSE_VALUE=8000000 USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\src;.\inc;.\Accelerometer_Drivers\inc;.\segment_display_drivers\inc;.\Moving_Average_Drivers\inc;.\keypad_drivers\inc;.\Accelerometer\inc;.\Temperature\inc;.\Alarm\inc;.\motor;.\proxy_sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c fputc_debug.c
  group Accelerometer_Drivers
    ./Accelerometer_Drivers/src/: lis3dsh.c lis302dl.c
  group Keypad
    ./keypad_drivers/src/: keypad.c
    ./keypad_drivers/inc/: keypad.h
  group Display
    ./segment_display_drivers/src/: segmentDisplay.c
    ./segment_display_drivers/inc/: segmentDisplay.h
  group Average
    ./Moving_Average_Drivers/inc/: movingAverageFloat.h
    ./Moving_Average_Drivers/src/: movingAverageFloat.c
  group Accelerometer
    ./Accelerometer/inc/: accelerometer.h
    ./Accelerometer/src/: accelerometer.c
  group Temperature
    ./Temperature/src/: temperature.c
    ./Temperature/inc/: temperature.h
  group Motor
    ./motor/: motor.c motor.h sweep.c sweep.h
  group proxy_sensor
    ./proxy_sensor/: ProximitySensor.c ProximitySensor.h
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.1/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.1.1/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/1.0.8/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    RTE/Device/STM32F407VG/: RTE_Device.h startup_stm32f40_41xxx.s stm32f4xx_conf.h system_stm32f4xx.c
software components: CMSIS:CORE 3.30.0, CMSIS:DSP 1.4.2, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:CAN 1.3.0, Device:StdPeriph Drivers:CRC 1.3.0, Device:StdPeriph Drivers:CRYP 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:DBGMCU 1.3.0, Device:StdPeriph Drivers:DCMI 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:FSMC 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:HASH 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SDIO 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
